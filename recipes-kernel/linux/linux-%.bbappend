FILESEXTRAPATHS:prepend := "${THISDIR}:"

SRC_URI += " \
    file://features/ar8035.cfg \
    file://features/rtl8211fs.cfg \
"
